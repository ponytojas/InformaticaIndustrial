# Keil uVision project main.uvproj, settings and files
target practica3 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: main
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group sourceFiles
    ./: startup_LPC17xx.s
    C:/Keil/ARM/Startup/NXP/LPC17xx/: system_LPC17xx.c
  group mainFiles
    C:/Keil/ARM/CMSIS/RTOS/: cmsis_os.h
    ./: main.c
